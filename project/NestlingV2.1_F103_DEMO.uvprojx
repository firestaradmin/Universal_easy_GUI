# Keil uVision project NestlingV2.1_F103_DEMO.uvprojx, settings and files
target NestlingV2.0_CPP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NestlingV2.0_CPP
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,STM32
  c include: ..\driver\FWLib\inc;..\driver\CORE;..\user;..\Bsp\TIM;..\Bsp\USART;..\Bsp\OLED_SSD1306;..\Bsp\delay;..\Bsp\UVGUI\include;..\Bsp\LCD;..\Bsp\24CXX;..\Bsp\IIC;..\lib\uvgui;..\lib\uvgui\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: stm32f10x_it.c stm32f10x_conf.h main.c
    ../user/: ug_port.c ug_user_config.h ug_port.h
  group BSP
    ../Bsp/LED/: LED.c
    ../Bsp/TIM/: myTIM.h myTIM.c
    ../Bsp/delay/: delay.c
    ../Bsp/W25QXX/: w25qxx.c w25qxx.h
    ../Bsp/SPI/: spi.c spi.h
    ../Bsp/USART/: usart.c
    ../Bsp/24CXX/: 24cxx.c
    ../Bsp/IIC/: myiic.c
  group CORE
    ../driver/CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group OLED
    ../Bsp/OLED_SSD1306/: OLED_CodeTab.h OLED_SSD1306.c OLED_SSD1306.h OLED_SSD1306_console.c OLED_SSD1306_console.h OLED_SSD1306_showCN.h OLED_SSD1306_showCN.c
  group ILI9341
    ../Bsp/LCD/: font.h LCD.c LCD.h
  group FWLib
    ../driver/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uvgui
    ../lib/uvgui/src/: ug_area.c ug_color.c ug_disp.c ug_draw_blend.c ug_draw_elements.c ug_draw_rect.c ug_label.c ug_ll.c ug_mem.c ug_obj.c ug_printf.c ug_refr.c ug_task.c ug_tick.c UVGUI.c
